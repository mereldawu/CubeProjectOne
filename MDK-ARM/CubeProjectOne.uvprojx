# Keil uVision project CubeProjectOne.uvprojx, settings and files
target CubeProjectOne Configuration (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: CubeProjectOne Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx
  c misc: --C99
  c include: ..\Inc; ..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32L0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l053xx.s
  group Application/User
    ../Src/: stm32l0xx_hal_msp.c stm32l0xx_it.c main.c gpio.c tim.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_rcc.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
